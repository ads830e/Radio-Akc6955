# IAR project radio_akc6955.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: user; stm32f0xx
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: radio_akc6955.hex
  ILINK.IlinkOutputFile: proj6.00_adc_uart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group stm32f030f4p6
    stm32f0xx/: arm_common_tables.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h startup_stm32f0xx.s stm32f0xx.h stm32f0xx_adc.c stm32f0xx_adc.h stm32f0xx_cec.c stm32f0xx_cec.h stm32f0xx_comp.c stm32f0xx_comp.h stm32f0xx_conf.h stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_dac.c stm32f0xx_dac.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_i2c.c stm32f0xx_i2c.h stm32f0xx_iwdg.c stm32f0xx_iwdg.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_pwr.c stm32f0xx_pwr.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_rtc.c stm32f0xx_rtc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h stm32f0xx_wwdg.c stm32f0xx_wwdg.h system_stm32f0xx.c system_stm32f0xx.h
  group user
    user/: main.c main.h stm32f030f4_userdef.h stm32f0xx_it.c stm32f0xx_it.h
